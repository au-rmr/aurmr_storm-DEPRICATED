Commit message: added collision boxes to IssacGym (collin)

File: content/assets/urdf/pod/pod.urdf (robot description, URDF)
Before this commit: robot pod1, 380 links, 379 joints
Links:
- link pod_base_link: geometry collision mesh filename=pod_frame.stl; visual mesh filename=pod_frame.stl
